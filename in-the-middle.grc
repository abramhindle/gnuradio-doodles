<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>CF</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>88.5e6</value></param>
<param><key>grid_pos</key><value>5,0, 1, 5</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>max</key><value>107.9e6</value></param>
<param><key>min</key><value>87.9e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>RF_Gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>13</value></param>
<param><key>grid_pos</key><value>6,0,1,5</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>max</key><value>45</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>45</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>variable_sample_rate_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1.000E6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>7, 0, 1, 5</value></param>
<param><key>label</key><value>Sample Rate: 1.024M, 1.4M, 1.8M, 1.92M, 2.048M, 2.4M &amp; 2. 56M</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>RTL820T</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>CF</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>RF_Gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>variable_sample_rate_0</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>50000</value></param>
<param><key>max_dev</key><value>12500</value></param>
<param><key>quad_rate</key><value>int(variable_sample_rate_0/5)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_1</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>5000</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>variable_sample_rate_0</value></param>
<param><key>width</key><value>8000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>50</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>RTL820T</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
